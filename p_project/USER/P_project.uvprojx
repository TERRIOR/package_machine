# Keil uVision project P_project.uvprojx, settings and files
target P_project (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: P_project +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\HARDWARE\HC05;..\USMART;..\HARDWARE\PWM;..\HARDWARE\RELAYS;..\HARDWARE\POSSWITCH;..\HARDWARE\LIGHTSWITCH;..\HARDWARE\MOTORLEI;..\HARDWARE\ADC;..\HARDWARE\MAX6675;..\HARDWARE\PID;..\HARDWARE\DCMOTOR;..\HARDWARE\HX711
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/RELAYS/: relays.c
    ../HARDWARE/POSSWITCH/: posswitch.c
    ../HARDWARE/LIGHTSWITCH/: lightswitch.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MOTORLEI/: motorlei.c
    ../HARDWARE/MAX6675/: max6675.c
    ../HARDWARE/PID/: PID.c
    ../HARDWARE/DCMOTOR/: dcmotor.c
    ../HARDWARE/HX711/: hx711.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_spi.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
